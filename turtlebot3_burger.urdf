Commit message: ready for m1

File: turtlebot3_burger.urdf (robot description, URDF)
Before this commit: robot turtlebot3_burger, 7 links, 6 joints
Links:
- link ${namespace}base_footprint: mass None -> 0.0001
- link ${namespace}imu_link: mass None -> 0.0001
